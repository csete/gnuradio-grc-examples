<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_rx_play</value></param>
<param><key>author</key><value>Alexandru Csete OZ9AEC</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>Simple narrow band FM receiver example.
http://oz9aec.net/radios/gnu-radio/grc-examples</value></param>
<param><key>description</key><value>Simple FM receiver</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FM Receiver (file player)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>:[8, 0, 1, 1]</value></param>
<param><key>label</key><value>Audio</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>quad_rate/audio_decim</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>coarse_tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>:[7, 0, 1, 2]</value></param>
<param><key>label</key><value>Coarse tune</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-sample_rate/2.0</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>sample_rate/2.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fine_tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>:[7, 2, 1, 1]</value></param>
<param><key>label</key><value>Fine tune</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_rate</value></param>
<param><key>value</key><value>sample_rate/quad_decim</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rf_freq</value></param>
<param><key>value</key><value>437900e3</value></param>
<param><key>gui_hint</key><value>:[0, 0, 1, 1]</value></param>
<param><key>label</key><value>RF freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>37</value></param>
<param><key>gui_hint</key><value>:[0, 2, 1, 1]</value></param>
<param><key>label</key><value>RF gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>rf_freq+(coarse_tune+fine_tune)</value></param>
<param><key>gui_hint</key><value>:[0, 1, 1, 1]</value></param>
<param><key>label</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1536000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sql_thld</value></param>
<param><key>value</key><value>-100</value></param>
<param><key>gui_hint</key><value>:[8, 1, 1, 1]</value></param>
<param><key>label</key><value>SQL</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, sample_rate, 0.45*quad_rate, 0.45*quad_rate/4, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>sql_thld</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx</value></param>
<param><key>const</key><value>af_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>channel_filter</value></param>
<param><key>cutoff_freq</key><value>12500</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>quad_rate</value></param>
<param><key>width</key><value>5000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>ddc</value></param>
<param><key>center_freq</key><value>-(coarse_tune+fine_tune)</value></param>
<param><key>decim</key><value>quad_decim</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>file_source</value></param>
<param><key>file</key><value>iqfile-2010.07.04.14.49.55.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>quad_rate</value></param>
<param><key>fc</key><value>rf_freq-(coarse_tune+fine_tune)</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>: [1, 0, 5, 3]</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink</value></param>
<param><key>gui_hint</key><value>:[8, 2, 1, 1]</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Signal:</value></param>
<param><key>unit1</key><value>dBFS</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx</source_block_id><sink_block_id>blocks_multiply_const_vxx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc</source_block_id><sink_block_id>analog_nbfm_rx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc</source_block_id><sink_block_id>blocks_complex_to_mag_squared</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared</source_block_id><sink_block_id>blocks_nlog10_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff</source_block_id><sink_block_id>qtgui_number_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle</source_block_id><sink_block_id>ddc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_filter</source_block_id><sink_block_id>analog_simple_squelch_cc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ddc</source_block_id><sink_block_id>channel_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ddc</source_block_id><sink_block_id>qtgui_freq_sink_x</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>file_source</source_block_id><sink_block_id>blocks_throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
